# Keil uVision project send_data_dma_to_gpio_pheripheral.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: send_data_dma_to_gpio_pheripheral
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c msp.c it.c
software components: CMSIS:CORE 5.3.0, Device:STM32Cube Framework:Classic 1.7.6, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:DMA 1.7.6, Device:STM32Cube HAL:EXTI 1.7.6, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:RCC 1.7.6, Device:STM32Cube HAL:SRAM 1.7.6, Device:STM32Cube HAL:TIM 1.7.6, Device:STM32Cube HAL:USART 1.7.6, Device:STM32Cube LL:Common 1.2.7, Device:STM32Cube LL:GPIO 1.2.7, Device:STM32Cube LL:PWR 1.2.7, Device:STM32Cube LL:RCC 1.2.7, Device:STM32Cube LL:USART 1.2.7, Device:STM32Cube LL:UTILS 1.2.7, Device:Startup 2.6.3
